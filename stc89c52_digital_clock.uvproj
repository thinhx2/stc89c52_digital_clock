# Keil uVision project stc89c52_digital_clock.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: stc89c52_digital_clock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Assembly
    ./: STARTUP.A51
  group Header
    ./src/: common.h utils.h led_seg.h ds1302.h keyboard.h
  group Source
    ./src/: utils.c led_seg.c ds1302.c keyboard.c main.c
